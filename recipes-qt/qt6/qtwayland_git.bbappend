PACKAGECONFIG:remove:rpi = "wayland-server"
PACKAGECONFIG:append:rpi = " wayland-client"
