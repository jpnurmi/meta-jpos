SUMMARY = "Slint printerdemo"

inherit slint_git

SLINT_PACKAGE = "printerdemo"
