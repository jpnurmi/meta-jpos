SUMMARY = "jpOS"
DESCRIPTION = "jpOS image"
LICENSE = "MIT"

inherit core-image
