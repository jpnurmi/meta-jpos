JPOS_TIMEZONE ?= "UTC"

DEFAULT_TIMEZONE = "${JPOS_TIMEZONE}"
